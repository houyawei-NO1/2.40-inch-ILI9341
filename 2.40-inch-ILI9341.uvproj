# Keil uVision project 2.40-inch-ILI9341.uvproj, settings and files
target Sample (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: 2-40-inch-ILI9341 +hex
  group Source
    ./: main.c
  group SRC
    ./SRC/LCD/: lcd_init.c lcd.c
